# Keil uVision project OLED.uvproj, settings and files
target QD-OLED (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TEST_OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group USR
    ./: main.c
  group SRC
    ./SRC/: oled.c
